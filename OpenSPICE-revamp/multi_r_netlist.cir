R1 1 0 1
R2 2 3 1
R3 1 2 4
R4 3 0 5
