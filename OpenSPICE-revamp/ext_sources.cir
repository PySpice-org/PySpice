V1 1 0 dc 0 external
R1 1 2 1
R2 2 3 1
I1 3 0 dc 0 external
